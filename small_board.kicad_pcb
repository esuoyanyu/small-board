# Repository esuoyanyu/small-board

File README.md:

This is small board, you can free use and modify it.

## KiCad design small_board.kicad_pcb

Parts:
C1, C3: 470nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C2, C4: 2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C5, C6, C7, C8: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C9, C14: 100nF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C10, C11, C12, C13: 12PF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J6: CONN_1_20_2.45mm
J2: SWD; CONN_1_04_P2.54mm
J3: BOOT SWITCH; CONN_2x03_P2.54mm
J7: USB C Power; USB_C_Receptacle_GCT_USB4135-GF-A_6P_TopMnt_Horizontal
R1, R2: 5.1KΩ; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R4: 1KΩ; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R5, R6, R7: 10KΩ; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW2: RESET; SW_SPST_B3U-1000P
U1: POWER; SOT-23-5
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 32.768KHZ; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y2: 8MHZ; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, J1.3, J1.20, J2.4, J3.1, J3.4, J6.1, R3.1, R5.1, U1.5 (OUT), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD)
+5V: C1.1, C2.2, J6.3, J7.A9 (VBUS), J7.B9 (VBUS), U1.1 (IN), U1.3 (EN)
/BOOT0: R6.1, U3.44 (BOOT0)
/BOOT1: R7.2, U3.20 (PB2)
/NRST: C14.1, J1.4, R5.2, SW2.2 (B), U3.7 (NRST)
/OSC32_IN: C11.1, J1.18, U3.3 (PC14), Y1.1
/OSC32_OUT: C10.2, J1.17, U3.4 (PC15), Y1.2
/OSC_IN: C13.2, U3.5 (PD0), Y2.1
/OSC_OUT: C12.1, U3.6 (PD1), Y2.3
/PA0: J1.16, U3.10 (PA0)
/PA1: J1.15, U3.11 (PA1)
/PA2: J1.14, U3.12 (PA2)
/PA3: J1.13, U3.13 (PA3)
/PA4: J1.12, U3.14 (PA4)
/PA5: J1.11, U3.15 (PA5)
/PA6: J1.10, U3.16 (PA6)
/PA7: J1.9, U3.17 (PA7)
/PA8: J6.16, U3.29 (PA8)
/PA9/USART1_TX: J6.15, U3.30 (PA9)
/PA10/USART1_RX: J6.14, U3.31 (PA10)
/PA13/SWDIO: J2.3, U3.34 (PA13)
/PA14/SWCLK: J2.2, U3.37 (PA14)
/PA15: J6.11, U3.38 (PA15)
/PB0: J1.8, U3.18 (PB0)
/PB1: J1.7, U3.19 (PB1)
/PB3: J6.10, U3.39 (PB3)
/PB4: J6.9, U3.40 (PB4)
/PB5: J6.8, U3.41 (PB5)
/PB6: J6.7, U3.42 (PB6)
/PB7: J6.6, U3.43 (PB7)
/PB8: J6.5, U3.45 (PB8)
/PB9: J6.4, U3.46 (PB9)
/PB10: J1.6, U3.21 (PB10)
/PB11: J1.5, U3.22 (PB11)
/PB12: J6.20, U3.25 (PB12)
/PB13: J6.19, U3.26 (PB13)
/PB14: J6.18, U3.27 (PB14)
/PB15: J6.17, U3.28 (PB15)
/PC13: J1.19, R4.1, U3.2 (PC13)
/USB_D+_PA12: J6.12, U3.33 (PA12)
/USB_D-_PA11: J6.13, U3.32 (PA11)
GND: C1.2, C2.1, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.1, C14.2, D1.1 (K), D2.1 (K), J1.1, J1.2, J2.1, J3.3, J3.6, J6.2, J7.A12 (GND), J7.B12 (GND), J7.S1 (SHIELD), R1.1, R2.2, SW2.1 (A), U1.2 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), Y2.2, Y2.4
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), R4.2
unnamed: J3.2, R6.2
unnamed: J3.5, R7.1
unnamed: J7.A5 (CC1), R1.2
unnamed: J7.B5 (CC2), R2.1
unnamed: C3.1, U1.4 (BP)

Notes on the sheet:
复位电路
SWD下载接口
晶振电路
主控滤波
STM32F103C8T6
POWER
拓展排针接口
LED指示灯

Board: 2 copper layers, 33 parts (18 on the bottom side), 49 nets, no tracks yet.

## Commit log

2025-04-24 smallboard: init. [1/1]
2025-04-24 small board: add readme.md
